# Keil uVision project stm32f103_c8.uvprojx, settings and files
target hw20_debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: powerbox_debug +hex
  AfterMake: fromelf --bin --output .\Objects\powerbox_debug.bin .\Objects\powerbox_debug.axf
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32_DEVICE_ID=0x410,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -DHARDWARE_V2_0 -DNO_TRACE_ALLOW_EXCEPTION -DCONFIG_SIZE_OPTIMIZE -DCONFIG_TRACE_USE_LOCAL_VSPRINTF=1 -DRAW_PRINT_ENABLE=0 -DCONFIG_TRACE_PRINT_UPTIME=0
  c include: ..\framework\source\component;..\framework\source\driver;..\framework\source\platform;..\framework\source\platform\stm32\stm32f10x;..\framework\third\SEGGER;..\framework\third\STM32F1xx_DFP\2.4.0\Device\StdPeriph_Driver\inc;..\framework\third\STM32F1xx_DFP\2.4.0\Device\Include;..\framework\third\CMSIS\5.8.0\CMSIS\Core\Include;..\src;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group component
    ../framework/source/component/console/: command.c console.c
    ../framework/source/component/stream_fifo/: stream_fifo.c
    ../framework/source/component/misc/: simple_crc.c string_helper.c
    ../framework/source/component/flow_task/: flow_task.c
    ../framework/source/component/npcp/slave/: npcp_slave.c npcp_slave_upgrade.c
    ../framework/source/component/npcp/lib/: npcp_frame.c
  group driver
    ../framework/source/driver/gpio/: gpio.c cli_gpio.c
    ../framework/source/driver/serial/: serial.c
    ../framework/source/driver/adc/: adc.c cli_adc.c
    ../framework/source/driver/can/: can.c cli_can.c
    ../framework/source/driver/i2c/: i2c.c
    ../framework/source/driver/sensor/sht3x/: sht3x.c cli_sht3x.c
    ../framework/source/driver/storage/: dual_block.c
  group platfrom
    ../framework/source/platform/stm32/: platform_private.c soc_adc.c soc_can.c soc_flash.c soc_gpio.c soc_i2c.c soc_info.c soc_uart.c sys_tick.c
    ../framework/source/platform/common/: trace.c
    ../framework/source/platform/stm32/stm32f10x/: stm32f10x_it.c
  group stm32f10x
    ../framework/third/STM32F1xx_DFP/2.4.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
    ../framework/third/STM32F1xx_DFP/2.4.0/Device/Source/: system_stm32f10x.c
    ../framework/third/STM32F1xx_DFP/2.4.0/Device/Source/ARM/: startup_stm32f10x_md.s
  group user
    ../src/: main.c board.c storage.c module_1kw.c module_5kw.c powerbox.c module.c sensor.c
target hw20_app_release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: powerbox_app +hex
  AfterMake: fromelf --bin --output .\Objects\powerbox_app.bin .\Objects\powerbox_app.axf
  AfterMake: mcuimage -v 4.3 -t 1 -o 512 -H -b 0x1000 -B ..\framework\project\mini_bootloader\released\mboot_stm32f103_4xx4_v1.0.2.bin -A .\Objects\powerbox_app.bin  powerbox_hw20
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_ENTRY=0x08001200,STM32_DEVICE_ID=0x410,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -DHARDWARE_V2_0 -DNO_TRACE -DCONFIG_SIZE_OPTIMIZE -DBUILD_RELEASED
  c include: ..\framework\source\component;..\framework\source\driver;..\framework\source\platform;..\framework\source\platform\stm32\stm32f10x;..\framework\third\STM32F1xx_DFP\2.4.0\Device\StdPeriph_Driver\inc;..\framework\third\STM32F1xx_DFP\2.4.0\Device\Include;..\framework\third\CMSIS\5.8.0\CMSIS\Core\Include;..\src;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x8001200 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target hw20_app_debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: powerbox_app_debug +hex
  AfterMake: fromelf --bin --output .\Objects\powerbox_app_debug.bin .\Objects\powerbox_app_debug.axf
  AfterMake: mcuimage -v 4.3 -t 1 -o 512 -H -b 0x1000 -B ..\framework\project\mini_bootloader\released\mboot_stm32f103_4xx4_v1.0.2.bin -A .\Objects\powerbox_app_debug.bin  powerbox_hw20_debug
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8001200 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x5000
