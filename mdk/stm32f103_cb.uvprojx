# Keil uVision project stm32f103_cb.uvprojx, settings and files
target hw31_debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: altibox_debug +hex
  AfterMake: fromelf --bin --output .\Objects\altibox_debug.bin .\Objects\altibox_debug.axf
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32_DEVICE_ID=0x410,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -DCONFIG_CONSOLE  -DCONFIG_SIZE_OPTIMIZE -DCONFIG_TRACE_VIA_RTT=1 -DCONFIG_DRIVER_I2C_GPIO_SIMULATE
  c include: ..\framework\source\component;..\framework\source\driver;..\framework\source\platform;..\framework\source\platform\stm32\stm32f10x;..\framework\third\SEGGER;..\framework\third\STM32F1xx_DFP\2.4.0\Device\StdPeriph_Driver\inc;..\framework\third\STM32F1xx_DFP\2.4.0\Device\Include;..\framework\third\CMSIS\5.8.0\CMSIS\Core\Include;..\src;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group component
    ../framework/source/component/console/: command.c console.c
    ../framework/source/component/stream_fifo/: stream_fifo.c
    ../framework/source/component/misc/: simple_crc.c string_helper.c date_time.c
    ../framework/source/component/flow_task/: flow_task.c
    ../framework/source/component/npcp/slave/: npcp_slave.c npcp_slave_upgrade.c
    ../framework/source/component/npcp/lib/: npcp_frame.c
  group driver
    ../framework/source/driver/gpio/: gpio.c cli_gpio.c
    ../framework/source/driver/serial/: serial.c
    ../framework/source/driver/adc/: adc.c cli_adc.c
    ../framework/source/driver/can/: can.c cli_can.c
    ../framework/source/driver/i2c/: i2c.c i2c_gpio.c
    ../framework/source/driver/sensor/sht3x/: sht3x.c cli_sht3x.c
    ../framework/source/driver/storage/: dual_block.c single_block.c
    ../framework/source/driver/rtc/: cli_rtc.c rtc.c
    ../framework/source/driver/eeprom/: i2c_eeprom.c
    ../framework/source/driver/sensor/bmp585/: bmp585.c
  group platfrom
    ../framework/source/platform/stm32/: platform_private.c soc_adc.c soc_can.c soc_flash.c soc_gpio.c soc_i2c.c soc_info.c soc_uart.c sys_tick.c soc_rtc.c
    ../framework/source/platform/common/: trace.c
    ../framework/source/platform/stm32/stm32f10x/: stm32f10x_it.c
  group stm32f10x
    ../framework/third/STM32F1xx_DFP/2.4.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
    ../framework/third/STM32F1xx_DFP/2.4.0/Device/Source/: system_stm32f10x.c
    ../framework/third/STM32F1xx_DFP/2.4.0/Device/Source/ARM/: startup_stm32f10x_md.s
  group user
    ../src/: main.c board.c storage.c sensor.c altibox.c
target hw31_app_release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: altibox_app +hex
  AfterMake: fromelf --bin --output .\Objects\altibox_app.bin .\Objects\altibox_app.axf
  AfterMake: mcuimage -v 1.11 -t b -o 512 -H -b 0x1000 -B ..\framework\project\mini_bootloader\released\mboot_stm32f103_4xx4_v1.0.2.bin -A .\Objects\altibox_app.bin  altibox_hw31
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_ENTRY=0x08001200,STM32_DEVICE_ID=0x410,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -DNO_TRACE -DCONFIG_SIZE_OPTIMIZE -DBUILD_RELEASED -DCONFIG_DRIVER_I2C_GPIO_SIMULATE
  c include: ..\framework\source\component;..\framework\source\driver;..\framework\source\platform;..\framework\source\platform\stm32\stm32f10x;..\framework\third\STM32F1xx_DFP\2.4.0\Device\StdPeriph_Driver\inc;..\framework\third\STM32F1xx_DFP\2.4.0\Device\Include;..\framework\third\CMSIS\5.8.0\CMSIS\Core\Include;..\src;..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x8001200 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
